# Keil uVision project lib_lpc_board_nxp_lpcxpresso_1549.uvprojx, settings and files
target nxp_lpcxpresso_1549 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: board_nxp_lpcxpresso_1549 (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_15xx;..\..\..\lpc_chip\chip_15xx\config_15xx;..\..\..\lpc_chip\chip_common;..\nxp_lpcxpresso_1549;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group board_nxp_lpcxpresso_1549
    ./: board.c board_sysinit.c
software components: CMSIS:CORE 4.3.0
