# Keil uVision project lib_lpc_chip_15xx.uvprojx, settings and files
target chip_15xx_lib (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: chip_15xx_lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_15xx;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS;.\config_15xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group csp
    ../chip_common/: ring_buffer.c eeprom.c iap.c
    ./: adc_15xx.c crc_15xx.c sysctl_15xx.c clock_15xx.c gpio_15xx.c iocon_15xx.c swm_15xx.c chip_15xx.c pmu_15xx.c sysinit_15xx.c uart_15xx.c rtc_15xx.c ritimer_15xx.c wwdt_15xx.c dma_15xx.c stopwatch_15xx.c acmp_15xx.c dac_15xx.c spi_15xx.c i2cm_15xx.c i2c_common_15xx.c i2cs_15xx.c sct_15xx.c sct_pwm_15xx.c
software components: CMSIS:CORE 4.3.0
